## src/vi/sdkconfig.defaults
```kconfig
CONFIG_ELF_DYNAMIC_LOAD_SHARED_OBJECT=y
CONFIG_ESP_SYSTEM_MEMPROT_PMS=n
CONFIG_ESP_SYSTEM_MEMPROT_PMS_LOCK=n
CONFIG_COMPILER_DISABLE_DEFAULT_ERRORS=y
```
